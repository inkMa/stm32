<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\407ZG_TFT.ewp</path>
  </project>
  <batchBuild />
</workspace>
